Commit message: Pointcloud publisher added

File: models/vik/model.urdf (robot description, URDF)
Before this commit: robot vikram, 6 links, 5 joints
Links:
- link depth_camera: mass 0.1 -> None
Joints:
- joint body_depthcam: origin xyz=0.8 0 1.2 rpy=0 0 0 -> xyz=0.8 0 1.17 rpy=0 0.2 0
